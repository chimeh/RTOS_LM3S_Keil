# Keil uVision project UCOS_TI_LM3S_Keil.uvproj, settings and files
target UCOS_TI_LM3S_Keil (ARM-ADS)
  device: LM3S1968 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: UCOS_TI_LM3S_Keil +hex
  BeforeMake: C:\MinGW\msys\1.0\bin\echo $D
  AfterMake: fromelf --bin --output .\UCOS_TI_LM3S_Keil.bin  .\Output\Obj\UCOS_TI_LM3S_Keil.axf
  c flags: Optim=1 oTime=1 wLevel=2
  c define: rvmdk
  c include: .;.\APP;.\BSP;.\DriverLib;.\DriverLib\driverlib;.\DriverLib\inc;.\DriverLib\RIT;.\uC-CPU;.\uC-LIB;.\uCOS-II\Ports;.\uCOS-II\Source;C:\Keil\ARM\RV31\INC;
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP_Gener
    ./APP/: app.c app_cfg.h cpu_cfg.h includes.h
    ./: Startup.s README
  group APP_OS
    ./APP/: os_app_hooks.c os_cfg.h
  group DriverLib_driverlib
    ./DriverLib/driverlib/: adc.c adc.h can.c can.h comp.c comp.h cpu_.c cpu_.h debug.h ethernet.c ethernet.h flash.c flash.h gpio.c gpio.h hibernate.c hibernate.h i2c.c i2c.h interrupt.c interrupt.h mpu.c mpu.h pin_map.h pwm.c pwm.h qei.c qei.h rom.h rom_map.h ssi.c ssi.h sysctl.c sysctl.h systick.c systick.h timer.c timer.h uart.c uart.h udma.c udma.h usb.c usb.h watchdog.c watchdog.h
  group DriverLib_inc
    ./DriverLib/inc/: asmdefs.h hw_adc.h hw_can.h hw_comp.h hw_ethernet.h hw_flash.h hw_gpio.h hw_hibernate.h hw_i2c.h hw_ints.h hw_memmap.h hw_nvic.h hw_pwm.h hw_qei.h hw_ssi.h hw_sysctl.h hw_timer.h hw_types.h hw_uart.h hw_udma.h hw_usb.h hw_watchdog.h lm3s1968.h lm3s3748.h lm3s6918.h lm3s6965.h
  group DriverLib_user
    ./DriverLib/RIT/: rit128x96x4.c rit128x96x4.h
  group BSP
    ./BSP/: cpu_bsp.c bsp.c bsp.h bsp_int.c bsp_int.h bsp_ser.c bsp_ser.h
    E:/WorkDIR/UCOS_Proj/UCOS_TI_LM3S_Keil/BSP/: bsp_os.c bsp_os.h
  group uC-CPU
    ./uC-CPU/: cpu_core.c cpu_core.h cpu_def.h cpu.h cpu_a_Ports.asm cpu_c_Ports.c
  group uC-LIB
    ./uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h lib_mem_a_Ports.asm
  group UCOS_Ports
    ./uCOS-II/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOS_Source
    ./uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
